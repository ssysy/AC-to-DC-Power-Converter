# Repository ssysy/AC-to-DC-Power-Converter

File README.md:

# AC-to-DC-Power-Converter
AC to DC Power Converter design and implementation

## KiCad design PCB_Board_KiCad_files/EEEE2046_PCB_Template.kicad_pcb

Board: 2 copper layers, 228.6 x 101.6 mm, 44 parts (0 on the bottom side), 21 nets.

Parts:
H1, H2, H3, H4: Mount; MountingHole_3.2mm_M3_Pad_Via
U1: TP_PWM_Out; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U1-Mosfet1, U2-Mosfet1, U3-Diode1, U4-Diode1: TO220_Heatsink
U3: TP_Q1_Gate; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U5: TC4425AVPA; DIP-8_W7.62mm_Socket_LongPads
U6: VS-KBPC606PBF; Diode_Bridge_Vishay_KBPC6
U7: TP_Q2_Gate; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U9: TP_DC_Link; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U11, U12: ECA2AM102; CP_Radial_D18.0mm_P7.50mm
U14, U18, U19: F; C_Rect_L7.0mm_W3.5mm_P2.50mm_P5.00mm
U15: Toroid-Transformer_1P_2S
U16, U20: IRFI530NPbF; TO-220FPAB
U17, U23, U31, U33: BYV25FX-600; SOD113
U21, U22: V; D_DO-35_SOD27_P7.62mm_Horizontal
U24, U25, U27, U28: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U26: ETD_34-Transformer_1P_1S; ETD_34-XMR
U34: H; ETD_34-L
U36, U38, U40: F; CP_Radial_D10.0mm_P2.50mm_P5.00mm
U37: 1uF; C_Rect_L7.0mm_W3.5mm_P2.50mm_P5.00mm
U39: 0.1 uF; C_Rect_L7.0mm_W3.5mm_P2.50mm_P5.00mm
U41: PWM_Power; 2wayTerminalBlock
U42: PWM_Input; LP-0841-3B-05A
U43: AC_Power; 2wayTerminalBlock
U44, U45: Converter_Out; 2wayTerminalBlock

Connections:
/Converter_Out(+): U34.1, U36.1, U38.1, U40.1, U44.1, U45.1
/Converter_Out(-): U26.3 (SA), U33.2 (A), U36.2, U38.2, U40.2, U44.2, U45.2
/PWM_COM_A: U3.2, U15.4 (SB), U20.3 (S), U21.2 (A), U23.1 (K), U26.1 (AA), U27.1
/PWM_COM_B: U6.3 (-), U7.2, U9.2, U11.2, U12.2, U15.6 (SD), U16.3 (S), U22.2 (A), U23.2 (A), U28.1
/PWM_Input: U5.4 (IN_B), U42.2
/PWM_OUT_A: U3.1, U20.1 (G), U24.1, U27.2
/PWM_OUT_B: U7.1, U16.1 (G), U25.1, U28.2
/PWM_Out: U1.1, U5.5 (OUT_B), U14.2
/Rectifier_DC(+): U6.1 (+), U9.1, U11.1, U12.1, U17.1 (K), U20.2 (D)
/Transformer_Out(+): U26.4 (SB), U31.2 (A)
/VAC(+): U6.4, U43.2
/VAC(-): U6.2, U43.1
GNDD: U1.2, U5.3 (GND), U15.2 (AB), U37.2, U39.2, U41.2, U42.1
unnamed: U14.1, U15.1 (AA)
unnamed: U15.3 (SA), U18.2
unnamed: U15.5 (SC), U19.2
unnamed: U16.2 (D), U17.2 (A), U26.2 (AB)
unnamed: U18.1, U21.1 (K), U24.2
unnamed: U19.1, U22.1 (K), U25.2
unnamed: U31.1 (K), U33.1 (K), U34.2
VDD: U5.6 (VDD), U37.1, U39.1, U41.1
